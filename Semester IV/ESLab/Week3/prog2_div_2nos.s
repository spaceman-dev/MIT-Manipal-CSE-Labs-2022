	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X40001000
	DCD Reset_Handler
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R6, =RESULT
	MOV R4, #0
	LDR R0, =VALUE1
	LDR R2, [R0]
	LDR R1, =VALUE2
	LDR R3, [R1]
UP	CMP R2, R3
	BCC	STORE
	SUB R2, R3
	ADD R4, #1
	B UP
STORE STR R4, [R6], #4
	STR R2, [R6]
STOP
	B STOP
VALUE1 DCD 10
VALUE2 DCD 2
	AREA mydata, DATA, READWRITE
RESULT DCD 0
	END