	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0, =VALUE1
	LDR R1, =VALUE2
	LDRB R2, [R0]
	LDRB R3, [R1]
	MOV R7, R2
	MOV R8, R3
BACK
	CMP R2, R3
	BEQ EXIT
	BCS DOWN
	SUB R3, R2
	B BACK
DOWN SUB R2, R3
	B BACK
EXIT
	LDR R0, =GCD
	STRB R2, [R0]
	LDR R6, =LCM
	MOV R5, #0
	MUL R7, R8
	LDR R4, [R0]
	CMP R4, #1
	BEQ PROD
UP
	SUB R7, R4
	ADD R5, #1
	CMP R7, #0
	BNE UP
	STR R5, [R6]
	B STOP
PROD STR R7, [R6]
STOP
	B STOP
VALUE1 DCD 2
VALUE2 DCD 10
	AREA mydata, DATA, READWRITE
GCD DCD 0
LCM DCD 0
	END