	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	MOV R4, #0
	MOV R1, #10
	LDR R0, =List
	LDR R2, =Result
UP	LDR R3, [R0, R4]
	STR R3, [R2, R4]
	ADD R4, #4
	SUB R1, #1
	CMP R1, #0
	BHI UP
	LDR R0, =Result
	MOV R3, #10
	SUB R3, R3, #1
	MOV R9, R3
OUTER_LOOP MOV R5, R0
	MOV R4, R3
INNER_LOOP LDR R6, [R5]
	LDR R7, [R5]
	CMP R7, R6
	STRLS R6, [R5]
	SUBS R4, R4, #1
	BNE INNER_LOOP
	SUB R3, #1
	SUBS R9, R9, #1
	BNE OUTER_LOOP
List DCD 0X10, 0X5, 0X33, 0X24, 0X56, 0X77, 0X21, 0X4, 0X87, 0X1
	AREA mydata, DATA, READWRITE
Result DCW 0,0,0,0,0,0,0,0,0,0
	END