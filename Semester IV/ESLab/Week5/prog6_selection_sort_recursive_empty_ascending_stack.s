	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	MOV R0, #3
	MOV R1, #5
	MOV R2, #4
	MOV R3, #1
	MOV R4, #2
	STM R13!, {R0-R4}
	MOV R5, #4
	MOV R6, #1
	MOV R12, R13
	MOV R2, R12
ABOVE CMP R6, R5
	BHI LAST
	MOV R7, R2
	MOV R10, R2
	MOV R8, #5
	ADD R9, R6, #1
UP CMP R9, R8
	BHI L2
L2	LDR R0, [R3]
	LDR R1, [R2]
	STR R0, [R2]
	STR R1, [R7]
	ADD R2, #4
	ADD R5, #4
	B ABOVE
LAST
	B LAST
List DCD 0X10, 0X5, 0X33, 0X24, 0X56, 0X77, 0X21, 0X4, 0X87, 0X1
	AREA mydata, DATA, READWRITE
Result DCW 0,0,0,0,0,0,0,0,0,0
	END